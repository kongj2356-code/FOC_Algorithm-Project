# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --split_sections
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\SensorFOC;.\MPU6050;.\QMC5883P
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --remove
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h IQ_math.c IQ_math.h EKF.c EKF.h sys.c sys.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Font.h Serial.c Serial.h bsp_tim.c bsp_tim.h
  group SensorFOC
    ./SensorFOC/PID/: bsp_pid.c bsp_pid.h
    ./SensorFOC/: MyI2C.c MyI2C.h
    ./SensorFOC/AS5600/: AS5600.c AS5600.h
    ./SensorFOC/FOC/: bsp_foc.c bsp_foc.h
    ./SensorFOC/ADC/: bsp_adc.c bsp_adc.h
  group MPU6050
    ./MPU6050/: IMU_I2C.c IMU_I2C.h MPU6050.c MPU6050.h MPU6050_Reg.h IMU_Pose_Estimation.c IMU_Pose_Estimation.h
  group QMC5883P
    ./QMC5883P/: QMC5883P.c QMC5883P.h QMC5883P_Reg.h
  group User
    ./User/: main.c headfile.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
