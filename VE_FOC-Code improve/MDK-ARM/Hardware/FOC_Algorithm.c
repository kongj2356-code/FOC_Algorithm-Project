/****************************************************************************************************
 * 文件功能说明：
 * 1. FOC 矢量控制核心算法实现
 * 2. Clarke / Park / 反Park / 反Clarke 坐标变换
 * 3. SVPWM 七段式矢量调制输出
 * 4. 电机零点定位（初始角度校准）
 * 5. PWM 周期计算与电机启停控制
****************************************************************************************************/
#include "FOC_Algorithm.h"
#include "FOC_math_utils.h"
#include "Upper.h"

/* F407主频 */
#define MAIN_CLOCK  168000000

/*********************************************************************
 * 函数功能：停止电机输出
 * 配置方法：将三相占空比全部设为0，关闭PWM输出
 * 调用位置：急停、故障保护、初始化未启动前
 ********************************************************************/
void stop_motor(void)
{
    // 三相PWM占空比置0，停止输出
    __HAL_TIM_SET_COMPARE(&htim1, TIM_CHANNEL_1, 0);
    __HAL_TIM_SET_COMPARE(&htim1, TIM_CHANNEL_2, 0);
    __HAL_TIM_SET_COMPARE(&htim1, TIM_CHANNEL_3, 0);
}



/*********************************************************************
 * 函数功能：电机零点校准（注电压定位法）
 * 输入参数：SVPWM结构体、电机参数结构体、编码器结构体
 * 实现原理：给d轴固定电压，电角度=0deg，电机转子会旋转到N极对齐方向
 *           等待稳定后读取100次编码器角度取平均，作为电机机械零点
 * 调用位置：电机上电初始化时，只执行一次
 ********************************************************************/
void Mechanical_zero_point_calibration(SVPWM_t* p1, Motor_t* p2, Encoder_t * p3)
{
    // 给d轴电压3V，q轴0V，电角度=0deg，强制转子定位到0电角度位置
    p1->Vd = 6;
    p1->Vq = 0;
    p1->elec_angle = 0;

    // 反park + 反clarke变换，将dq电压转为三相电压
    reverse_park(p1);
    reverse_clarke(p1);

    // SVPWM计算并输出PWM，使电机转子定位
    SVPWM_Calculate(p1);

    // 等待2秒，转子稳定不动
    HAL_Delay(2000);

    // 连续读取100次编码器角度求平均值，作为机械零点
    float sum = 0;
    for(int i=0; i<100; i++)
    {
        p3->mec_angle = AS5600_Get_Angle_Degrees();
        sum += p3->mec_angle;
    }

    // 平均角度存入电机零点参数
    p2->zero_encoder_angle = sum / 100;

   Sendarray_Init();
   Float_send(SendArray, 3);  // 角度数据发送（调试用）

    HAL_GPIO_TogglePin(GPIOA, GPIO_PIN_7);  //完整后D3灯电平翻转
}



/*********************************************************************
 * 函数功能：计算PWM周期时间 Tpwm
 * 实现原理：中心对齐模式下，周期 = 2 * ARR * (PSC/主频)
 * 输出结果：p->Tpwm = PWM周期时间（单位：秒）
 ********************************************************************/
void calculate_period(SVPWM_t *p)
{
    uint32_t psc_value = TIM1->PSC + 1;  // 定时器预分频值
    uint32_t arr_value = TIM1->ARR;      // 自动重装载值（PWM周期）

    // 中心对齐模式：计数方向上下各一次，总周期 = 2*ARR个时钟
    p->Tpwm = 2.0F / (MAIN_CLOCK / (psc_value * arr_value));
}




/*********************************************************************
 * 函数功能：Clarke变换（三相电流 → 两相静止坐标系 Iα、Iβ）
 * 输入：Ia、Ib（三相电流，Ic可推导）
 * 输出：Iα、Iβ
 ********************************************************************/
void clarke(SVPWM_t *p)
{
    p->Ialpha = p->Ia;                                  // Iα = A相电流
    p->Ibeta  = (2 * p->Ib + p->Ia) / _SQRT3;           // Iβ 计算公式
}




/*********************************************************************
 * 函数功能：Park变换（静止坐标系 → 旋转坐标系 Id、Iq）
 * 输入：Iα、Iβ、电角度
 * 输出：Id（励磁电流）、Iq（转矩电流）
//要注意顺序，先给Uq，再给Ud
 ********************************************************************/
void park(SVPWM_t *p, PID_t* p1, PID_t* p2)
{
    p->Iq = -p->Ialpha * fast_sin(p->elec_angle) + p->Ibeta * fast_cos(p->elec_angle);
    p->Id =  p->Ialpha * fast_cos(p->elec_angle) + p->Ibeta * fast_sin(p->elec_angle);
}



/*********************************************************************
 * 函数功能：反Park变换（旋转dq → 静止αβ）
 * 输入：Vd、Vq、电角度
 * 输出：Vα、Vβ
//输入是机械角度,但是要换成电角度进行计算,直接输入机械角度
 ********************************************************************/
void reverse_park(SVPWM_t *p)
{
    p->Valpha = fast_cos(p->elec_angle) * p->Vd - fast_sin(p->elec_angle) * p->Vq;
    p->Vbeta  = fast_cos(p->elec_angle) * p->Vq + fast_sin(p->elec_angle) * p->Vd;
}


/*********************************************************************
 * 函数功能：反Clarke变换（αβ → 三相电压 Ua、Ub、Uc）
 * 输入：Vα、Vβ
 * 输出：Va、Vb、Vc
 ********************************************************************/
void reverse_clarke(SVPWM_t *p)
{
    p->Va = p->Vbeta;
    p->Vb = (_SQRT3 * p->Valpha - p->Vbeta) / 2.0F;
    p->Vc = -(_SQRT3 * p->Valpha + p->Vbeta) / 2.0F;
}


/*********************************************************************
 * 函数功能：SVPWM 七段式计算核心
 * 实现步骤：
 * 1. 根据Va/Vb/Vc正负判断扇区(1~6)
 * 2. 计算基本矢量作用时间 T1、T2
 * 3. 过调制限制
 * 4. 计算三相比较值 Ta、Tb、Tc
 * 5. 根据扇区分配到三相通道
 * 6. 计算CCR值并直接输出PWM
 ********************************************************************/
void SVPWM_Calculate(SVPWM_t *p){
    calculate_period(p);
    float T1,T2;//这是中间的计算变量
    p->sector = 0.0F;
    p->Tcomp1 = 0.0F;
    p->Tcomp2 = 0.0F;
    p->Tcomp3 = 0.0F;

    if(p->Va> 0.0F){
        p->sector = 1;
    }
    if(p->Vb>0.0F){
        p->sector += 2;
    }
    if(p->Vc>0.0F){
        p->sector += 4;
    }

    /*差之毫厘,失之千里,这里计算出来的值不正确
    X = _SQRT3*Vbeta*(Tpwm/Vdc);
    Y = (Tpwm/Vdc)*((3/2)*Valpha + SQRT3_Half*Vbeta);
    Z = (Tpwm/Vdc)*((-3/2)*Valpha + SQRT3_Half*Vbeta);
    */
    //中间变量XYZ
    p->X = _SQRT3*p->Vbeta*(p->Ts/p->Vdc);
    p->Y = (p->Ts/p->Vdc)*(3*p->Valpha + _SQRT3*p->Vbeta)/2;
    p->Z = (p->Ts/p->Vdc)*(-3*p->Valpha + _SQRT3*p->Vbeta)/2;

    switch (p->sector){
        case 1:
            T1 =  p->Z;
            T2 =  p->Y;
            break;
        case 2:
            T1 = p->Y;
            T2 = -p->X;
            break;
        case 3:
            T1 = -p->Z;
            T2 = p->X;
            break;
        case 4:
            T1 = -p->X;
            T2 = p->Z;
            break;
        case 5:
            T1 = p->X;
            T2 = -p->Y;
            break;
        case 6:
            T1 = -p->Y;
            T2 = -p->Z;
            break;
        default:
            break;
    }
    //过调制处理
    if (T1 + T2 > p->Ts){
        T1 = T1/(T1 + T2);
        T2 = T2/(T1 + T2);
    }
    else{
        T1=T1;
        T2=T2;
    }
    //计算Ta,Tb,Tc
    p->Ta = 0.5f * (p->Ts - T1 - T2);
    p->Tb = p->Ta + T1;
    p->Tc = p->Tb + T2;
    //这个是可以的
    
//    p->Ta = (p->Ts - (T1 + T2))/4.0F;
//    p->Tb = p->Ta+(T1 / 2.0F);
//    p->Tc = p->Tb+(T2 / 2.0F);//这个是袁雷书上的代码,但是出来得波形幅值会减半
    
    switch (p->sector){
        case 1:
            p->Tcomp1 = p->Tb;
            p->Tcomp2 = p->Ta;
            p->Tcomp3 = p->Tc;
            break;
        case 2:
            p->Tcomp1 = p->Ta;
            p->Tcomp2 = p->Tc;
            p->Tcomp3 = p->Tb;
            break;
        case 3:
            p->Tcomp1 = p->Ta;
            p->Tcomp2 = p->Tb;
            p->Tcomp3 = p->Tc;
            break;
        case 4:
            p->Tcomp1 = p->Tc;
            p->Tcomp2 = p->Tb;
            p->Tcomp3 = p->Ta;
            break;
        case 5:
            p->Tcomp1 = p->Tc;
            p->Tcomp2 = p->Ta;
            p->Tcomp3 = p->Tb;
            break;
        case 6:
            p->Tcomp1 = p->Tb;
            p->Tcomp2 = p->Tc;
            p->Tcomp3 = p->Ta;
            break;
    }
    
    //Tcpm1,Tcpm2,Tcpm3就已经是占空比了所以直接乘上ARR就行                                   
    //占空比计算(TIM1挂在在APB2总线上f=84MHz，中央对齐模式下，三相频率=168000000Hz/(0+1)/(3499+1)/2=24K)
    p->Tcomp1 = p->Tcomp1*(TIM1->ARR);
    p->Tcomp2 = p->Tcomp2*(TIM1->ARR);
    p->Tcomp3 = p->Tcomp3*(TIM1->ARR);
    //最终加载到定时器上面作为输出
    __HAL_TIM_SET_COMPARE(&htim1,TIM_CHANNEL_1,p->Tcomp1);
    __HAL_TIM_SET_COMPARE(&htim1,TIM_CHANNEL_2,p->Tcomp2);
    __HAL_TIM_SET_COMPARE(&htim1,TIM_CHANNEL_3,p->Tcomp3);//最终加载
}
